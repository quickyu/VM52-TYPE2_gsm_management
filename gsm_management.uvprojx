# Keil uVision project gsm_management.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F100C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gsm_management +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\src\include;.\src\include\freertos;.\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group src
    ./src/: main.c serial.c
  group freertos
    ./src/freertos/: croutine.c event_groups.c heap_4.c list.c port.c queue.c tasks.c timers.c
software components: CMSIS:CORE 4.1.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
